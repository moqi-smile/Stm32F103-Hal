# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Application\Eval;..\Middlewares\Contiki\core\sys;..\Middlewares\Contiki\core;..\Middlewares\Contiki\cpu;..\Application\Peripheral\Radio
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group Driver/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_timebase_tim_template.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_spi.c stm32f1xx_hal_pwr.c
  group MDK/User
    ../Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group Middlewares/Comtiki/Sys
    ../Middlewares/Contiki/core/sys/: process.c ctimer.c etimer.c timer.c
  group Middlewares/Comtiki/Lib
    ../Middlewares/Contiki/core/lib/: list.c memb.c mmem.c
  group Middlewares/Comtiki/Cpu
    ../Middlewares/Contiki/cpu/: clock.c
  group Application/Peripheral/Radio
    ../Application/Peripheral/Radio/: radio.c sx1276.c sx1276-Fsk.c sx1276-FskMisc.c sx1276-Hal.c sx1276-LoRa.c sx1276-LoRaMisc.c
  group Application/Eval
    ../Application/Eval/: Eval.c
    ../Application/Eval/Gpio/: Gpio.c
    ../Application/Eval/Usart/: Usart.c
    ../Application/Eval/Iwdg/: Iwdg.c
    ../Application/Eval/Spi/: Spi.c
    ../Application/Eval/Tim/: Tim.c
    ../Application/Eval/Rtc/: Rtc.c
    ../Application/Eval/FLASH/: Flash.c
  group Application
    ../Application/: Application.c UartApplication.c RTCApplication.c RadioApplication.c MotorApplication.c
